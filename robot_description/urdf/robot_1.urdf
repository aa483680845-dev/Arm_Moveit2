Commit message: 添加visual_rviz可视化部分

File: robot_description/urdf/robot_1.urdf (robot description, URDF)
Before this commit: robot robot_1, 7 links, 6 joints
Joints:
- joint joint_5: limit lower=-3 upper=3 effort=7 velocity=3 -> lower=-1.57 upper=1.57 effort=7 velocity=3
